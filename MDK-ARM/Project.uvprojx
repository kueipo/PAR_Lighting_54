# Keil uVision project Project.uvprojx, settings and files
target PY32F002Ax5_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\PY32F0xx\Source\arm;..\Drivers\PY32F0xx_HAL_Driver\Src;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\BspDriver\GPIO;..\BspDriver\Timer;..\BspDriver\Usart;..\BspDriver\ADC;..\BspDriver\SysClock;..\User;..\BspDriver\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f002xx.s
  group Application
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group User
    ../User/: Timer.c LEDFunc.c KeyFunc.c NixiteTube.c NixiteTube_Driver.c EEPROM.c Led.c
  group BspDriver
    ../BspDriver/GPIO/: BspDriver_GPIO.c
    ../BspDriver/Usart/: BspDriver_Usart.c
    ../BspDriver/SysClock/: BspDriver_SysClk.c
    ../BspDriver/Timer/: BspDriver_Timer16.c BspDriver_Timer1.c
    ../BspDriver/IWDG/: BspDriver_IWDG.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
